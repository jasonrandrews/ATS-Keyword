# Keil uVision project tfm.kws_ns.uvprojx, settings and files
target kws_ns (6160000::V6.16::ARMCLANG)
  device: ARMCM55 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x30000000,0x00020000) IRAM2(0x20000000,0x00020000) IROM(0x10000000,0x00200000) IROM2(0x00000000,0x00200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: tfm_ns
  c flags: Optim=3 v6Lang=5 v6LangP=8 wLevel=1
  c misc: -g
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT5: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x30000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: ./bsp/an547_ns.sct
  link misc: --cpu=Cortex-M55 --info=summarysizes,sizes,totals,unused,veneers --diag_suppress=6312 --diag_suppress=6314 --diag_suppress=6304 --diag_suppress=6329 --summary_stderr --load_addr_map_info build/secure_partition/s_veneers.o
  group tfm_api_ns
    ./lib/tf-m/interface/src/: tfm_firmware_update_func_api.c tfm_platform_func_api.c tfm_audit_func_api.c tfm_ps_func_api.c tfm_its_func_api.c tfm_crypto_func_api.c tfm_initial_attestation_func_api.c
    ./lib/tfm_test/app/: tfm_ns_interface.c
  group platform_ns
    ./lib/tf-m/platform/ext/target/arm/mps3/an547/cmsis_drivers/: Driver_Flash.c Driver_USART.c
    ./lib/tf-m/platform/ext/target/arm/mps3/an547/device/source/: device_definition.c system_core_init.c
    ./lib/tf-m/platform/ext/target/arm/mps3/an547/native_drivers/: systimer_armv8-m_drv.c uart_cmsdk_drv.c syscounter_armv8-m_cntrl_drv.c arm_mps3_io_drv.c smsc9220_eth_drv.c ppc_sse300_drv.c
    ./lib/tf-m/platform/ext/target/arm/mps3/an547/: plat_test.c
  group freertos_ns
    ./bsp/freertos-platform/: application_helpers.c print_log.c lan91c111.c NetworkInterface.c
    ./lib/amazon_freertos/freertos_kernel/portable/GCC/ARM_CM33_NTZ/non_secure/: port.c portasm.c
    ./lib/amazon_freertos/freertos_kernel/: list.c queue.c tasks.c stream_buffer.c timers.c event_groups.c
    ./lib/amazon_freertos/freertos_kernel/portable/MemMang/: heap_4.c
    ./lib/amazon_freertos/freertos_kernel/portable/ThirdParty/GCC/ARM_CM33_TFM/: os_wrapper_freertos.c
    ./kws/ota/ota_for_aws/source/: ota.c ota_base64.c ota_cbor.c ota_http.c ota_interface.c ota_mqtt.c
    ./kws/ota/ota_for_aws/source/portable/os/: ota_os_freertos.c
    ./kws/ota/ota_for_aws/source/dependency/coreJSON/source/: core_json.c
    ./kws/ota/ota_for_aws/source/dependency/3rdparty/tinycbor/src/: cborencoder.c cborencoder_close_container_checked.c cborerrorstrings.c cborparser.c cborparser_dup_string.c cborpretty.c cborpretty_stdio.c cbortojson.c cborvalidation.c open_memstream.c
    ./kws/ota/ota_pal_psa/: ota_pal.c
    ./kws/ota/ota_pal_psa/version/: application_version.c
    ./kws/ota/: ota_demo_core_mqtt.c
    ./kws/ota/provision/: ota_provision.c
    ./lib/amazon_freertos/demos/common/mqtt_subscription_manager/: mqtt_subscription_manager.c
    ./lib/amazon_freertos/demos/common/ota_demo_helpers/: ota_application_version.c
    ./lib/amazon_freertos/demos/common/pkcs11_helpers/: pkcs11_helpers.c
    ./lib/amazon_freertos/demos/coreMQTT_Agent/: mqtt_agent_task.c simple_sub_pub_demo.c subscription_manager.c
    ./lib/amazon_freertos/demos/demo_runner/: aws_demo.c aws_demo_network_addr.c iot_demo_freertos.c iot_demo_runner.c
    ./lib/amazon_freertos/demos/network_manager/: aws_iot_network_manager.c
    ./lib/amazon_freertos/libraries/coreHTTP/source/: core_http_client.c
    ./lib/amazon_freertos/libraries/coreHTTP/source/dependency/3rdparty/http_parser/: http_parser.c
    ./lib/amazon_freertos/libraries/coreMQTT-Agent/source/: core_mqtt_agent.c core_mqtt_agent_command_functions.c
    ./lib/amazon_freertos/libraries/c_sdk/standard/https/src/: iot_https_client.c iot_https_utils.c
    ./lib/amazon_freertos/libraries/abstractions/mqtt_agent/: freertos_command_pool.c freertos_agent_message.c
    ./lib/amazon_freertos/demos/dev_mode_key_provisioning/src/: aws_dev_mode_key_provisioning.c
    ./lib/amazon_freertos/demos/common/mqtt_demo_helpers/: mqtt_demo_helpers.c
    ./lib/amazon_freertos/demos/common/http_demo_helpers/: http_demo_utils.c
    ./lib/amazon_freertos/libraries/logging/: iot_logging.c iot_logging_task_dynamic_buffers.c
    ./lib/amazon_freertos/libraries/freertos_plus/standard/freertos_plus_tcp/portable/BufferManagement/: BufferAllocation_2.c
    ./lib/amazon_freertos/libraries/freertos_plus/standard/freertos_plus_tcp/: FreeRTOS_ARP.c FreeRTOS_DHCP.c FreeRTOS_DNS.c FreeRTOS_IP.c FreeRTOS_Sockets.c FreeRTOS_Stream_Buffer.c FreeRTOS_TCP_IP.c FreeRTOS_TCP_WIN.c FreeRTOS_UDP_IP.c
    ./lib/amazon_freertos/libraries/abstractions/platform/freertos/: iot_clock_freertos.c iot_metrics.c iot_network_freertos.c iot_threads_freertos.c
    ./lib/amazon_freertos/libraries/abstractions/secure_sockets/freertos_plus_tcp/: iot_secure_sockets.c
    ./lib/amazon_freertos/libraries/c_sdk/standard/common/: iot_device_metrics.c iot_init.c iot_static_memory_common.c
    ./lib/amazon_freertos/libraries/c_sdk/standard/common/taskpool/: iot_taskpool.c iot_taskpool_static_memory.c
    ./lib/amazon_freertos/libraries/c_sdk/standard/mqtt/src/: iot_mqtt_agent.c iot_mqtt_api.c iot_mqtt_context_connection.c iot_mqtt_managed_function_wrapper.c iot_mqtt_mutex_wrapper.c iot_mqtt_network.c iot_mqtt_operation.c iot_mqtt_publish_duplicates.c iot_mqtt_serializer_deserializer_wrapper.c iot_mqtt_static_memory.c iot_mqtt_subscription.c iot_mqtt_subscription_container.c iot_mqtt_validate.c
    ./lib/amazon_freertos/libraries/coreMQTT/source/: core_mqtt.c core_mqtt_state.c core_mqtt_serializer.c
    ./lib/amazon_freertos/libraries/abstractions/backoff_algorithm/source/: backoff_algorithm.c
    ./lib/amazon_freertos/libraries/abstractions/transport/secure_sockets/: transport_secure_sockets.c
    ./lib/amazon_freertos/libraries/freertos_plus/standard/tls/src/: iot_tls.c
    ./lib/amazon_freertos/libraries/freertos_plus/standard/crypto/src/: iot_crypto.c
    ./lib/amazon_freertos/libraries/3rdparty/mbedtls_utils/: mbedtls_error.c mbedtls_utils.c
    ./lib/amazon_freertos/libraries/abstractions/pkcs11/corePKCS11/source/: core_pkcs11.c core_pki_utils.c
    ./lib/amazon_freertos/libraries/abstractions/pkcs11/psa/: iot_pkcs11_psa.c iot_pkcs11_psa_input_format.c iot_pkcs11_psa_object_management.c
    ./lib/amazon_freertos/libraries/3rdparty/mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group ml_kit_ns
    ./lib/ml-embedded-evaluation-kit/source/application/tensorflow-lite-micro/: TensorFlowLiteMicro.cc Model.cc
    ./lib/ml-embedded-evaluation-kit/source/application/main/: Classifier.cc Profiler.cc Mfcc.cc PlatformMath.cc
    ./lib/ml-embedded-evaluation-kit/source/use_case/kws/src/: DsCnnModel.cc
  group ml_gen_ns
    ./lib/ml-embedded-evaluation-kit/generated/kws/src/: ds_cnn_clustered_int8_vela_H128.tflite.cc ds_cnn_labels.cc
  group audio_drv
    ./lib/VHT/interface/audio/driver/: audio_drv.c
  group tfm_ns-cpp
    ./kws/source/: ml_interface.cc model_config.cc
    ./lib/ml-embedded-evaluation-kit/dependencies/tensorflow/tensorflow/lite/micro/cortex_m_generic/: debug_log.cc
  group tfm_ns
    ./lib/tf-m/platform/ext/target/arm/mps3/an547/device/source/: startup_an547_ns.c
    ./kws/source/: blink_task.c main_ns.c
    ./bsp/source/: serial.c
  group cmsis-dsp
    ./lib/ml-embedded-evaluation-kit/dependencies/cmsis/CMSIS/DSP/Source/BasicMathFunctions/: arm_abs_f16.c arm_abs_f32.c arm_abs_q15.c arm_abs_q31.c arm_abs_q7.c arm_add_f16.c arm_add_f32.c arm_add_q15.c arm_add_q31.c arm_add_q7.c arm_and_u16.c arm_and_u32.c arm_and_u8.c arm_clip_f16.c arm_clip_f32.c arm_clip_q15.c arm_clip_q31.c arm_clip_q7.c arm_dot_prod_f16.c arm_dot_prod_f32.c arm_dot_prod_q15.c arm_dot_prod_q31.c arm_dot_prod_q7.c arm_mult_f16.c arm_mult_f32.c arm_mult_q15.c arm_mult_q31.c arm_mult_q7.c arm_negate_f16.c arm_negate_f32.c arm_negate_q15.c arm_negate_q31.c arm_negate_q7.c arm_not_u16.c arm_not_u32.c arm_not_u8.c arm_offset_f16.c arm_offset_f32.c arm_offset_q15.c arm_offset_q31.c arm_offset_q7.c arm_or_u16.c arm_or_u32.c arm_or_u8.c arm_scale_f16.c arm_scale_f32.c arm_scale_q15.c arm_scale_q31.c arm_scale_q7.c arm_shift_q15.c arm_shift_q31.c arm_shift_q7.c arm_sub_f16.c arm_sub_f32.c arm_sub_q15.c arm_sub_q31.c arm_sub_q7.c arm_xor_u16.c arm_xor_u32.c arm_xor_u8.c
    ./lib/ml-embedded-evaluation-kit/dependencies/cmsis/CMSIS/DSP/Source/CommonTables/: arm_common_tables.c arm_common_tables_f16.c arm_const_structs.c arm_const_structs_f16.c arm_mve_tables.c arm_mve_tables_f16.c
    ./lib/ml-embedded-evaluation-kit/dependencies/cmsis/CMSIS/DSP/Source/ComplexMathFunctions/: arm_cmplx_conj_f32.c arm_cmplx_dot_prod_f32.c arm_cmplx_mag_f32.c arm_cmplx_mag_squared_f32.c arm_cmplx_mult_cmplx_f32.c arm_cmplx_mult_real_f32.c arm_cmplx_mult_cmplx_q15.c arm_cmplx_mult_cmplx_q31.c
    ./lib/ml-embedded-evaluation-kit/dependencies/cmsis/CMSIS/DSP/Source/FastMathFunctions/: arm_cos_f32.c arm_cos_q15.c arm_cos_q31.c arm_sin_f32.c arm_sin_q15.c arm_sin_q31.c arm_sqrt_q15.c arm_sqrt_q31.c arm_vexp_f16.c arm_vexp_f32.c arm_vinverse_f16.c arm_vlog_f16.c arm_vlog_f32.c
    ./lib/ml-embedded-evaluation-kit/dependencies/cmsis/CMSIS/DSP/Source/StatisticsFunctions/: arm_entropy_f16.c arm_entropy_f32.c arm_entropy_f64.c arm_kullback_leibler_f16.c arm_kullback_leibler_f32.c arm_kullback_leibler_f64.c arm_logsumexp_dot_prod_f16.c arm_logsumexp_dot_prod_f32.c arm_logsumexp_f16.c arm_logsumexp_f32.c arm_max_f16.c arm_max_f32.c arm_max_no_idx_f16.c arm_max_no_idx_f32.c arm_max_q15.c arm_max_q31.c arm_max_q7.c arm_mean_f16.c arm_mean_f32.c arm_mean_q15.c arm_mean_q31.c arm_mean_q7.c arm_min_f16.c arm_min_f32.c arm_min_q15.c arm_min_q31.c arm_min_q7.c arm_power_f16.c arm_power_f32.c arm_power_q15.c arm_power_q31.c arm_power_q7.c arm_rms_f16.c arm_rms_f32.c arm_rms_q15.c arm_rms_q31.c arm_std_f16.c arm_std_f32.c arm_std_q15.c arm_std_q31.c arm_var_f16.c arm_var_f32.c arm_var_q15.c arm_var_q31.c
    ./lib/ml-embedded-evaluation-kit/dependencies/cmsis/CMSIS/DSP/Source/TransformFunctions/: arm_bitreversal.c arm_bitreversal2.c arm_bitreversal_f16.c arm_cfft_f16.c arm_cfft_f32.c arm_cfft_f64.c arm_cfft_init_f16.c arm_cfft_init_f32.c arm_cfft_init_f64.c arm_cfft_init_q15.c arm_cfft_init_q31.c arm_cfft_q15.c arm_cfft_q31.c arm_cfft_radix2_f16.c arm_cfft_radix2_f32.c arm_cfft_radix2_init_f16.c arm_cfft_radix2_init_f32.c arm_cfft_radix2_init_q15.c arm_cfft_radix2_init_q31.c arm_cfft_radix2_q15.c arm_cfft_radix2_q31.c arm_cfft_radix4_f16.c arm_cfft_radix4_f32.c arm_cfft_radix4_init_f16.c arm_cfft_radix4_init_f32.c arm_cfft_radix4_init_q15.c arm_cfft_radix4_init_q31.c arm_cfft_radix4_q15.c arm_cfft_radix4_q31.c arm_cfft_radix8_f16.c arm_cfft_radix8_f32.c arm_dct4_f32.c arm_dct4_init_f32.c arm_dct4_init_q15.c arm_dct4_init_q31.c arm_dct4_q15.c arm_dct4_q31.c arm_rfft_f32.c arm_rfft_fast_f16.c arm_rfft_fast_f32.c arm_rfft_fast_f64.c arm_rfft_fast_init_f16.c arm_rfft_fast_init_f32.c arm_rfft_fast_init_f64.c arm_rfft_init_f32.c arm_rfft_init_q15.c arm_rfft_init_q31.c arm_rfft_q15.c arm_rfft_q31.c
  group tensor-flow
    ./lib/ml-embedded-evaluation-kit/dependencies/tensorflow/tensorflow/lite/c/: common.c
  group tensor-flow-cpp
    ./lib/ml-embedded-evaluation-kit/dependencies/tensorflow/tensorflow/lite/micro/: simple_memory_allocator.cc all_ops_resolver.cc memory_helpers.cc test_helpers.cc recording_micro_allocator.cc micro_error_reporter.cc micro_time.cc recording_simple_memory_allocator.cc micro_string.cc micro_profiler.cc micro_utils.cc micro_interpreter.cc micro_allocator.cc
    ./lib/ml-embedded-evaluation-kit/dependencies/tensorflow/tensorflow/lite/micro/memory_planner/: linear_memory_planner.cc greedy_memory_planner.cc
    ./lib/ml-embedded-evaluation-kit/dependencies/tensorflow/tensorflow/lite/core/api/: error_reporter.cc flatbuffer_conversions.cc op_resolver.cc tensor_utils.cc
    ./lib/ml-embedded-evaluation-kit/dependencies/tensorflow/tensorflow/lite/kernels/internal/: quantization_util.cc
    ./lib/ml-embedded-evaluation-kit/dependencies/tensorflow/tensorflow/lite/kernels/: kernel_util.cc
    ./lib/ml-embedded-evaluation-kit/dependencies/tensorflow/tensorflow/lite/schema/: schema_utils.cc
  group tensor-flow-kernels
    ./lib/ml-embedded-evaluation-kit/dependencies/tensorflow/tensorflow/lite/micro/kernels/: activations.cc arg_min_max.cc batch_to_space_nd.cc cast.cc ceil.cc circular_buffer.cc comparisons.cc concatenation.cc conv_common.cc depthwise_conv_common.cc dequantize.cc detection_postprocess.cc elementwise.cc elu.cc exp.cc flexbuffers_generated_data.cc floor.cc fully_connected_common.cc hard_swish.cc kernel_runner.cc kernel_util.cc l2norm.cc logical.cc logistic.cc maximum_minimum.cc neg.cc pack.cc pad.cc prelu.cc quantize.cc quantize_common.cc reduce.cc reshape.cc resize_nearest_neighbor.cc round.cc shape.cc softmax_common.cc space_to_batch_nd.cc split.cc split_v.cc strided_slice.cc sub.cc svdf_common.cc tanh.cc transpose_conv.cc unpack.cc zeros_like.cc
    ./lib/ml-embedded-evaluation-kit/dependencies/tensorflow/tensorflow/lite/micro/kernels/cmsis_nn/: add.cc conv.cc depthwise_conv.cc fully_connected.cc mul.cc pooling.cc softmax.cc svdf.cc
    ./lib/ml-embedded-evaluation-kit/dependencies/tensorflow/tensorflow/lite/micro/kernels/ethos_u/: ethosu.cc
  group driver
    ./lib/ml-embedded-evaluation-kit/dependencies/cmsis/CMSIS/NN/Source/ConcatenationFunctions/: arm_concatenation_s8_w.c arm_concatenation_s8_y.c arm_concatenation_s8_z.c arm_concatenation_s8_x.c
    ./lib/ml-embedded-evaluation-kit/dependencies/cmsis/CMSIS/NN/Source/SVDFunctions/: arm_svdf_s8.c
    ./lib/ml-embedded-evaluation-kit/dependencies/cmsis/CMSIS/NN/Source/NNSupportFunctions/: arm_nn_mult_q15.c arm_q7_to_q15_with_offset.c arm_nn_depthwise_conv_nt_t_padded_s8.c arm_nn_mat_mult_nt_t_s8.c arm_q7_to_q15_no_shift.c arm_nn_mult_q7.c arm_nntables.c arm_nn_accumulate_q7_to_q15.c arm_nn_mat_mul_core_4x_s8.c arm_nn_vec_mat_mult_t_s8.c arm_nn_add_q7.c arm_q7_to_q15_reordered_no_shift.c arm_nn_depthwise_conv_nt_t_s8.c arm_nn_mat_mul_core_1x_s8.c arm_q7_to_q15_reordered_with_offset.c
    ./lib/ml-embedded-evaluation-kit/dependencies/cmsis/CMSIS/NN/Source/BasicMathFunctions/: arm_elementwise_mul_s8.c arm_elementwise_add_s8.c
    ./lib/ml-embedded-evaluation-kit/dependencies/cmsis/CMSIS/NN/Source/SoftmaxFunctions/: arm_softmax_s8.c arm_softmax_with_batch_q7.c arm_softmax_u8.c arm_softmax_q15.c arm_softmax_q7.c
    ./lib/ml-embedded-evaluation-kit/dependencies/cmsis/CMSIS/NN/Source/ActivationFunctions/: arm_relu_q15.c arm_relu_q7.c arm_relu6_s8.c arm_nn_activations_q15.c arm_nn_activations_q7.c
    ./lib/ml-embedded-evaluation-kit/dependencies/cmsis/CMSIS/NN/Source/FullyConnectedFunctions/: arm_fully_connected_q15.c arm_fully_connected_q7.c arm_fully_connected_q7_opt.c arm_fully_connected_mat_q7_vec_q15.c arm_fully_connected_mat_q7_vec_q15_opt.c arm_fully_connected_q15_opt.c arm_fully_connected_s8.c
    ./lib/ml-embedded-evaluation-kit/dependencies/cmsis/CMSIS/NN/Source/ReshapeFunctions/: arm_reshape_s8.c
    ./lib/ml-embedded-evaluation-kit/dependencies/cmsis/CMSIS/NN/Source/ConvolutionFunctions/: arm_depthwise_conv_3x3_s8.c arm_convolve_1x1_s8_fast.c arm_convolve_HWC_q15_fast_nonsquare.c arm_convolve_HWC_q7_fast_nonsquare.c arm_nn_mat_mult_kernel_s8_s16.c arm_depthwise_conv_wrapper_s8.c arm_convolve_HWC_q15_fast.c arm_nn_mat_mult_kernel_q7_q15.c arm_depthwise_separable_conv_HWC_q7.c arm_convolve_HWC_q7_fast.c arm_convolve_1_x_n_s8.c arm_depthwise_conv_s8.c arm_convolve_HWC_q7_basic_nonsquare.c arm_nn_depthwise_conv_s8_core.c arm_depthwise_conv_u8_basic_ver1.c arm_depthwise_conv_s8_opt.c arm_convolve_wrapper_s8.c arm_nn_mat_mult_kernel_s8_s16_reordered.c arm_convolve_HWC_q7_RGB.c arm_convolve_1x1_HWC_q7_fast_nonsquare.c arm_nn_mat_mult_s8.c arm_convolve_HWC_q15_basic.c arm_convolve_HWC_q7_basic.c arm_nn_mat_mult_kernel_q7_q15_reordered.c arm_convolve_s8.c arm_depthwise_separable_conv_HWC_q7_nonsquare.c
    ./lib/ml-embedded-evaluation-kit/dependencies/cmsis/CMSIS/NN/Source/PoolingFunctions/: arm_avgpool_s8.c arm_pool_q7_HWC.c arm_max_pool_s8.c
    ./lib/ml-embedded-evaluation-kit/dependencies/core-driver/src/: ethosu_pmu.c ethosu_device.c ethosu_driver.c
  group timing-adapter
    ./lib/ml-embedded-evaluation-kit/dependencies/core-software/drivers/timing_adapter/src/: timing_adapter.c
  group main
    ./lib/ml-embedded-evaluation-kit/source/application/hal/platforms/bare-metal/bsp/bsp-core/: retarget.c

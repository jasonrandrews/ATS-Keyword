# Keil uVision project tfm.blinky_ns.uvprojx, settings and files
target blinky_ns (6160000::V6.16::ARMCLANG)
  device: ARMCM55 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x30000000,0x00020000) IRAM2(0x20000000,0x00020000) IROM(0x10000000,0x00200000) IROM2(0x00000000,0x00200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: tfm_ns
  c flags: Optim=1 v6Lang=5 v6LangP=1 wLevel=2
  c misc: -g
  memory RVCT4: RAM 0x10000000 size 0x200000
  memory RVCT5: RAM 0x0 size 0x200000
  memory RVCT9: ROM 0x30000000 size 0x20000
  memory RVCT10: ROM 0x20000000 size 0x20000
  scatter file: ./bsp/an547_ns.sct
  link misc: --cpu=Cortex-M55 --info=summarysizes,sizes,totals,unused,veneers --diag_suppress=6312 --diag_suppress=6314 --diag_suppress=6304 --diag_suppress=6329 --summary_stderr --load_addr_map_info build/secure_partition/s_veneers.o
  group tfm_api_ns
    ./lib/tf-m/interface/src/: tfm_firmware_update_func_api.c tfm_platform_func_api.c tfm_audit_func_api.c tfm_ps_func_api.c tfm_its_func_api.c tfm_crypto_func_api.c tfm_initial_attestation_func_api.c
    ./lib/tfm_test/app/: tfm_ns_interface.c
  group platform_ns
    ./lib/tf-m/platform/ext/target/arm/mps3/an547/cmsis_drivers/: Driver_Flash.c Driver_USART.c
    ./lib/tf-m/platform/ext/target/arm/mps3/an547/device/source/: device_definition.c system_core_init.c
    ./lib/tf-m/platform/ext/target/arm/mps3/an547/native_drivers/: systimer_armv8-m_drv.c uart_cmsdk_drv.c syscounter_armv8-m_cntrl_drv.c arm_mps3_io_drv.c smsc9220_eth_drv.c ppc_sse300_drv.c
    ./lib/tf-m/platform/ext/target/arm/mps3/an547/: plat_test.c
  group freertos_ns
    ./bsp/freertos-platform/: application_helpers.c print_log.c
    ./lib/amazon_freertos/freertos_kernel/portable/GCC/ARM_CM33_NTZ/non_secure/: port.c portasm.c
    ./lib/amazon_freertos/freertos_kernel/: list.c queue.c tasks.c stream_buffer.c timers.c event_groups.c
    ./lib/amazon_freertos/freertos_kernel/portable/MemMang/: heap_4.c
    ./lib/amazon_freertos/freertos_kernel/portable/ThirdParty/GCC/ARM_CM33_TFM/: os_wrapper_freertos.c
  group tfm_ns
    ./lib/tf-m/platform/ext/target/arm/mps3/an547/device/source/: startup_an547_ns.c
    ./blinky/: main_ns.c freertos_adaptation.c
    ./bsp/source/: serial.c
